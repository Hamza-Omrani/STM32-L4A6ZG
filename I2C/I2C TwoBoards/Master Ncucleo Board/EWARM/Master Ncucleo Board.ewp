# IAR project Master Ncucleo Board.ewp, settings and files
configuration Master Ncucleo Board (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4A6ZG ST STM32L4A6ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4A6xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; C:\Users\hamza.omrani\Desktop\I2C TwoBoards\Master Ncucleo Board\Drivers\BSP\STM32L4xx_Nucleo_144
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Master Ncucleo Board.hex
  ILINK.IlinkOutputFile: Master Ncucleo Board.out
  ILINK.IlinkIcfFile: stm32l4a6xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l4a6xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l4xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
